inherit core-image

IMAGE_INSTALL += "my-app"
