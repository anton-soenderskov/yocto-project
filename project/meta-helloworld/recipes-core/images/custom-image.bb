require recipes-core/images/core-image-minimal.bb

DESCRIPTION = "A minimal image with the helloworld application."

IMAGE_INSTALL += "application"
